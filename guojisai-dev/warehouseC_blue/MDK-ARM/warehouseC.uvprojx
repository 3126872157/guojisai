# Keil uVision project warehouseC.uvprojx, settings and files
target warehouseC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: warehouseC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Arm;../Tasks;../Compoents;../Application;../Boards;../Compoents/algorithm;../Compoents/algorithm/Include;../Compoents/devices
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group algorithm
    ../Compoents/algorithm/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_sc000.h core_sc300.h
    ../Compoents/algorithm/: AHRS_middleware.c AHRS_middleware.h arm_cortexM4lf_math.lib user_lib.c user_lib.h AHRS.h AHRS.lib
  group devices
    ../Compoents/devices/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h
  group Boards
    ../Boards/: bsp_can.c bsp_can.h bsp_delay.c bsp_delay.h bsp_flash.c bsp_flash.h bsp_imu_pwm.c bsp_imu_pwm.h bsp_spi.c bsp_spi.h bsp_buzzer.c bsp_buzzer.h
  group Arm
    ../Arm/: A1_motor_msg.h arm_ctrl.c arm_ctrl.h arm_solver.c arm_solver.h serial_servo.c serial_servo.h unitree_a1.c unitree_a1.h
  group Application
    ../Application/: bodanpan.c bodanpan.h CAN_receive.c CAN_receive.h chassis_behaviour.c chassis_behaviour.h detect_task.c detect_task.h Gray_sensor.c Gray_sensor.h pid.c pid.h struct_typedef.h UART_receive.c UART_receive.h vofa.c vofa.h IO_Serial.c IO_Serial.h oled.c OLED_Font.h oled.h
  group Tasks
    ../Tasks/: arm_control_task.c arm_control_task.h arm_task.c arm_task.h Bodanpan_Task.c Bodanpan_Task.h Chassis_Task.c Chassis_Task.h flow_task.c flow_task.h INS_task.c INS_task.h calibrate_task.c calibrate_task.h oled_task.c oled_task.h
software components: CMSIS:CORE 4.3.0
